Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: PAA-Washbasins-Silkstone-Do-25-IDO25-XX-3D.IFC
Time: 2024-06-07T06:35:20
Author: PC Lite
Written by: SwIFC
Made in: SolidWorks 2018

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: PAA-Washbasins-Silkstone-Do-25-IDO25-XX-3D
In: Default Storey
Material: 0
